# Keil uVision project ESC001V1.uvprojx, settings and files
target ESC001V1 (ARM-ADS)
  device: STM32F303CBTx STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: ESC001V1 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F303xC
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.4.3/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.4.3/MotorControl/MCSDK/MCLib/F3xx/Inc;../MCSDK_v5.4.3/MotorControl/MCSDK/UILibrary/Inc;../MCSDK_v5.4.3/MotorControl/MCSDK/SystemDriveParams;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_comp.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.3/MotorControl/lib/: libmc-keil_M4.lib
    ../MCSDK_v5.4.3/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.3/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_1_f30x_pwm_curr_fdbk.c
    ../MCSDK_v5.4.3/MotorControl/MCSDK/UILibrary/Src/: frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
software components: CMSIS:CORE 4.3.0
